# Keil uVision project Main.uvprojx, settings and files
target main (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Main +hex
  BeforeMake: time.bat > buildTime.h
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o  "update.bin" "#L"
  AfterMake: cp.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Inc;    ..\app;    ..\app_cpp;    ..\Src\Ethernet;    ..\Src\Ethernet\W5500;    ..\port;    ..\fifo\inc;    ../Drivers/CMSIS/Include;    ../Drivers/STM32F4xx_HAL_Driver/Inc;    ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;    ../Middlewares/Third_Party/FatFs/src;    ../Middlewares/Third_Party/FreeRTOS/Source/include;    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;    ..\Middlewares\Third_Party\FreeRTOS\Source\cli;    ..\MDK-ARM;    ..\Middlewares\Third_Party\httpServer;    ..\Middlewares\Third_Party\modbus\include\common;    ..\Middlewares\Third_Party\modbus\include\internal;    ..\Middlewares\Third_Party\modbus\include;    ..\Middlewares\Third_Party\modbus\port
  asm include: ..\\Inc;..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0xe0000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/src
    ../Middlewares/Third_Party/FreeRTOS/Source/cli/: CLI-commands.c
    ../app/: app.c MotorCan.c AGV_Parallel_Motion.cpp CANOpenSample.cpp W5500.cpp Battery.cpp httpAPI.c listRunTask.c BeltDriveController.cpp modbusTask.c
    ../app_cpp/: Motor.cpp
  group Application/User
    ../Src/: main.c gpio.c adc.c can.c dac.c dma.c bsp_driver_sd.c sd_diskio.c fatfs.c fatfs_platform.c freertos.c iwdg.c rtc.c sdio.c spi.c sys.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ./: startup_stm32f429xx.s
    ../Src/: system_stm32f4xx.c
  group W5500/HAL
    ../Src/Ethernet/W5500/: w5500.c
  group W5500/socket
    ../Src/Ethernet/: socket.c wizchip_conf.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/cli/: FreeRTOS_CLI.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group port
    ../port/: hardware.c
  group fifo
    ../fifo/lib/: fifo.cpp
  group Middleware/httpd
    ../Middlewares/Third_Party/httpServer/: httpParser.c httpServer.c httpUtil.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Modbus/Kernel
    ../Middlewares/Third_Party/modbus/common/: mbutils.c
    ../Middlewares/Third_Party/modbus/functions/: mbmfunccoils.c mbmfunccustom1.c mbmfuncdisc.c mbmfuncfiles.c mbmfuncholding.c mbmfuncinput.c mbmfuncraw.c mbmfuncslaveid.c
    ../Middlewares/Third_Party/modbus/rtu/: mbmcrc.c mbmrtu.c
    ../Middlewares/Third_Party/modbus/: mbm.c
  group Modbus/Port
    ../Middlewares/Third_Party/modbus/port/: mbportevent.c mbportother.c mbportserial.c mbporttimer.c
software components: CMSIS:CORE 5.1.2
